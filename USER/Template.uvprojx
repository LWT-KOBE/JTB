# Keil uVision project Template.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Template +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1
  c define: STM32F10X_MD,USE_STDPERIPH_DRIVER
  c include: ..\SYSTEM\delay;..\SYSTEM\sys;..\USER;..\STM32F10x_FWLib\inc;..\CORE;..\FWLIB\STM32F10x_FWLib\inc;..\HARDWARE\KEY;..\HARDWARE\SPI;..\HARDWARE\FLASH;..\MALLOC;..\MALLOC;..\USMART;..\EMWIN\STemWin\Config;..\EMWIN\STemWin\inc;..\EMWIN\Demo;..\EMWIN\Demo;..\SYSTEM\usart;..\SYSTEM\include;..\HARDWARE\DMA;..\HARDWARE\timer;..\HARDWARE\OLED;..\HARDWARE\CAN;..\HARDWARE\IAP_APP;..\HARDWARE\motor;..\HARDWARE\EXTI;..\HARDWARE\APP
  memory RVCT4: ROM 0x8000000 size 0xe000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group USER
    ./: main.c stm32f10x_it.c system_stm32f10x.c
  group HARDWARE
    ../HARDWARE/KEY/: key.c
    ../HARDWARE/CAN/: can.c SEGGER_RTT.c SEGGER_RTT_printf.c
    ../HARDWARE/timer/: timer.c
    ../HARDWARE/IAP_APP/: iap_APP.c
    ../HARDWARE/APP/: BSP_eeprom.c app.c task.c AD.c
    ../HARDWARE/motor/: motor.c
    ../HARDWARE/OLED/: oled.c
    ../HARDWARE/EXTI/: exti.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
    ../SYSTEM/include/: include.h
  group CORE
    ../CORE/: core_cm3.c startup_stm32f10x_md.s
  group FWLIB
    ../FWLIB/STM32F10x_FWLib/src/: misc.c stm32f10x_crc.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_can.c stm32f10x_adc.c stm32f10x_pwr.c stm32f10x_wwdg.c stm32f10x_bkp.c stm32f10x_cec.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_flash.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_rtc.c stm32f10x_sdio.c
    ../FWLIB/STM32F10x_FWLib/inc/: stm32f10x_pwr.h
